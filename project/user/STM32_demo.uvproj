# Keil uVision project STM32_demo.uvproj, settings and files
target STM32_demo (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32_demo +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\user;..\CMSIS;..\lib\inc;..\lib\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTCODE
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c stm32f10x_conf.h rcc_conf.c usart1_conf.c i2c_conf.c mpu6050.c time.c MadgwickAHRS.c EulerAngles.c tim_conf.c usart2_conf.c DesireAngles.c pwm_motor.c PID_control.c crc_check.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group LIB
    ../lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_tim.c
